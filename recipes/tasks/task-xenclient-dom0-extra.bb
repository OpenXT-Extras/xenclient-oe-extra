DESCRIPTION = "Extra packages required for OpenXT dom0"
LICENSE = "Proprietary"
PR = "r14"

inherit task

RDEPENDS_${PN} = " \
"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

